Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 48260ced-52c6-4bb8-8c37-79e471192114, NumberOfSaves: 1]
File name: 0001
Time: 2025-09-19T07:02:56+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12190350_CN_KM3736C:26373652_CN_12190350_KM3736C, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 780 mm; Height: 80 mm; Depth: 450 mm
Classification: E1090320 Uniformat (Uniformat); Material: z_Miele_Design_OBSW, z_Miele_Design_Cast, <Unnamed>, z_Miele_Design_CLST, z_Miele_Connection_Gas, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - Reference: 26373652_CN_12190350_KM3736C; sets with these values: 2
